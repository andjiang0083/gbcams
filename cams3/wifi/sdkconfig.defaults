## cams3/wifi/sdkconfig.defaults
```kconfig
# sdkconfig overrides for cams3_fw
CONFIG_SCCB_CLK_FREQ=100000
CONFIG_SCCB_HARDWARE_I2C_PORT1=y
CONFIG_ESP_CONSOLE_USB_SERIAL_JTAG=y
```
